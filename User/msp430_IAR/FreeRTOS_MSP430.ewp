# IAR project FreeRTOS_MSP430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ; ..\Common\include; ..\..\os\include; ..\..\os\portable\MSP430X
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group App
    ./: interrupt.c main.c
    serial/: serial.c
  group Drivers
    ../Common/Minimal/: flash.c
    ../Common/drivers/: hmc5883l.c i2c.c mpu9050.c nrf24l01.c pwm.c
    ParTest/: ParTest.c
    serial/: serialASM.s43
  group Kernel
    ../../os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Kernel/mem
    ../../os/portable/MemMang/: heap_1.c
  group Kernel/portable
    ../../os/portable/MSP430/: port.c portext.s43
