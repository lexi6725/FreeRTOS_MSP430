# IAR project RTOSDemo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ; ..\Common\include; ..\..\os\include; ..\..\os\portable\MSP430
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group OS
    ../../os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group OS/Portable
    ../../os/portable/MemMang/: heap_1.c
    ../../os/portable/MSP430/: port.c portext.s43
  group User/BSP
    ./: main.c
    ParTest/: ParTest.c
    serial/: serialASM.s43
  group User/Dirvers
    ../Common/Minimal/: flash.c
